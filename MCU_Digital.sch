File: MCU_Digital.sch (KiCad schematic (older format))
At the start: 48 parts

Commit message: Annotated and plotted
Parts:
- gave numbers to parts that had none: 44
